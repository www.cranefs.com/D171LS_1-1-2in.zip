# Autodesk Inventor part: D171LS_1 1-2in
## iProperties
Created: 2011-02
Part Number: D171LS_1 1-2in
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
